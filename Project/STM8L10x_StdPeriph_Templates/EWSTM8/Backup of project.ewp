# IAR project Backup of project.ewp, settings and files
configuration stm8l10x (STM8, debug)
  General.GenDeviceSelectMenu: STM8L101K3T STM8L101K3T
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: USE_STDPERIPH_DRIVER
  ICCSTM8.CCIncludePath2: ..; ..\..\..\Libraries\STM8L10x_StdPeriph_Driver\inc; ..\..\..\Utilities\STM8L101_EVAL; ..\..\..\Utilities\STM8L101_EVAL\Common
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: project.srec
  ILINK.IlinkOutputFile: stm8l101-eval.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group STM8L101_EVAL
    ../../../Utilities/STM8L101_EVAL/: stm8l101_eval.c
    ../../../Utilities/STM8L101_EVAL/Common/: stm8l_eval_lcd.c
  group StdPeriph_Drivers
    ../../../Libraries/STM8L10x_StdPeriph_Driver/src/: stm8l10x_awu.c stm8l10x_beep.c stm8l10x_clk.c stm8l10x_comp.c stm8l10x_exti.c stm8l10x_flash.c stm8l10x_gpio.c stm8l10x_i2c.c stm8l10x_irtim.c stm8l10x_itc.c stm8l10x_iwdg.c stm8l10x_rst.c stm8l10x_spi.c stm8l10x_tim2.c stm8l10x_tim3.c stm8l10x_tim4.c stm8l10x_usart.c stm8l10x_wfe.c
  group User
    ../: main.c stm8l10x_it.c
